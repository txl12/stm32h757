<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\H757XI_SDRAM_Test.ewp</path>
  </project>
  <batchBuild />
</workspace>
