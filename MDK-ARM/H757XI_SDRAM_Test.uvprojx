# Keil uVision project H757XI_SDRAM_Test.uvprojx, settings and files
target H757XI_SDRAM_Test_CM4 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H757XIHx:CM4 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.8.0
  cpu: IRAM(0x10000000-0x10047FFF) IRAM2(0x18000000-0x1800FFFF) IROM(0x8100000-0x81FFFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M4") TZ
  output: H757XI_SDRAM_Test_CM4 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: CORE_CM4,USE_HAL_DRIVER,STM32H757xx
  c include: ../CM4/Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include
  asm include: ../CM4/Core/Inc
  memory RVCT4: ROM 0x8100000 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x48000
  memory RVCT10: RAM 0x18000000 size 0x10000
  scatter file: stm32h757xx_flash_CM4.sct
  group Application/MDK-ARM
    ./: startup_stm32h757xx_CM7.s startup_stm32h757xx_CM4.s
  group Application/User/CM4/Core
    ../CM4/Core/Src/: main.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Application/User/CM7/Core
    ../CM7/Core/Src/: main.c gpio.c crc.c dma2d.c fmc.c freertos.c i2c.c ltdc.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_dma2d.c stm32h7xx_ll_fmc.c stm32h7xx_hal_sdram.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Common/Src/: system_stm32h7xx_dualcore_boot_cm4_cm7.c
  group Application/User/CM7/TouchGFX/App
    ../CM7/TouchGFX/App/: app_touchgfx.c
  group Application/User/CM7/TouchGFX/target
    ../CM7/TouchGFX/target/: TouchGFXHAL.cpp STM32TouchController.cpp TouchGFXGPIO.cpp
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Lib
    ../cm7/middlewares/st/touchgfx/lib/core/cortex_m7/Keil/: touchgfx_core.lib
  group Application/User/CM7/TouchGFX/target/generated
    ../CM7/TouchGFX/target/generated/: TouchGFXConfiguration.cpp TouchGFXGeneratedHAL.cpp STM32DMA.cpp OSWrappers.cpp
  group gui
    ../cm7/touchgfx/gui/src/settings_screen/: analogclockwithsettimefunctionality.cpp clockselectorcontainer.cpp datepicker.cpp dateselectorcontainer.cpp settingspresenter.cpp settingsview.cpp timesettingcontainer.cpp wheelselector.cpp
    ../cm7/touchgfx/gui/src/common/: carousel.cpp circularvalueindicator.cpp dotindicator.cpp frontendapplication.cpp swipecontainer.cpp zoomanimationbox.cpp
    ../cm7/touchgfx/gui/src/game2d_screen/: collectibleitem.cpp game2dpresenter.cpp game2dview.cpp parallaxbackground.cpp
    ../cm7/touchgfx/gui/src/controls_screen/: controlspresenter.cpp controlsview.cpp
    ../cm7/touchgfx/gui/src/game2048_screen/: game2048presenter.cpp game2048view.cpp gameboard.cpp
    ../cm7/touchgfx/gui/src/homeautomation_screen/: graph.cpp graphline.cpp homeautomationpresenter.cpp homeautomationview.cpp loginwidget.cpp roomcontrol.cpp roomcontroladjustable.cpp roomcontroltoggle.cpp roomcontrolwheel.cpp statisticscontainer.cpp
    ../cm7/touchgfx/gui/src/mainmenuanimatingbuttons_screen/: mainmenuanimatingbuttonspresenter.cpp mainmenuanimatingbuttonsview.cpp
    ../cm7/touchgfx/gui/src/mainmenucarousel_screen/: mainmenucarouselpresenter.cpp mainmenucarouselview.cpp
    ../cm7/touchgfx/gui/src/containers/: mculoadwidget.cpp
    ../cm7/touchgfx/gui/src/model/: model.cpp
  group generated
    ../cm7/touchgfx/generated/fonts/src/: applicationfontprovider.cpp cachedfont.cpp font_asap_bold_otf_20_4bpp_0.cpp font_asap_bold_otf_27_4bpp_0.cpp font_asap_regular_18_4bpp_0.cpp font_asap_regular_20_4bpp_0.cpp font_asap_regular_21_4bpp_0.cpp font_asap_regular_28_4bpp_0.cpp font_asap_regular_42_4bpp_0.cpp font_roboto_bold_22_4bpp_0.cpp font_roboto_medium_30_4bpp_0.cpp font_robotocondensed_bold_22_4bpp_0.cpp font_robotocondensed_bold_30_4bpp_0.cpp font_robotocondensed_bold_32_4bpp_0.cpp font_robotocondensed_bold_42_4bpp_0.cpp font_robotocondensed_bold_56_4bpp_0.cpp font_robotocondensed_bold_60_4bpp_0.cpp font_robotocondensed_bold_90_4bpp_0.cpp font_robotocondensed_regular_110_4bpp_0.cpp font_robotocondensed_regular_22_4bpp_0.cpp font_robotocondensed_regular_38_4bpp_0.cpp font_robotocondensed_regular_54_4bpp_0.cpp fontcache.cpp generatedfont.cpp kerning_asap_bold_otf_20_4bpp.cpp kerning_asap_bold_otf_27_4bpp.cpp kerning_asap_regular_18_4bpp.cpp kerning_asap_regular_20_4bpp.cpp kerning_asap_regular_21_4bpp.cpp kerning_asap_regular_28_4bpp.cpp kerning_asap_regular_42_4bpp.cpp kerning_roboto_bold_22_4bpp.cpp kerning_roboto_medium_30_4bpp.cpp kerning_robotocondensed_bold_22_4bpp.cpp kerning_robotocondensed_bold_30_4bpp.cpp kerning_robotocondensed_bold_32_4bpp.cpp kerning_robotocondensed_bold_42_4bpp.cpp kerning_robotocondensed_bold_56_4bpp.cpp kerning_robotocondensed_bold_60_4bpp.cpp kerning_robotocondensed_bold_90_4bpp.cpp kerning_robotocondensed_regular_110_4bpp.cpp kerning_robotocondensed_regular_22_4bpp.cpp kerning_robotocondensed_regular_38_4bpp.cpp kerning_robotocondensed_regular_54_4bpp.cpp table_asap_bold_otf_20_4bpp.cpp table_asap_bold_otf_27_4bpp.cpp table_asap_regular_18_4bpp.cpp table_asap_regular_20_4bpp.cpp table_asap_regular_21_4bpp.cpp table_asap_regular_28_4bpp.cpp table_asap_regular_42_4bpp.cpp table_roboto_bold_22_4bpp.cpp table_roboto_medium_30_4bpp.cpp table_robotocondensed_bold_22_4bpp.cpp table_robotocondensed_bold_30_4bpp.cpp table_robotocondensed_bold_32_4bpp.cpp table_robotocondensed_bold_42_4bpp.cpp table_robotocondensed_bold_56_4bpp.cpp table_robotocondensed_bold_60_4bpp.cpp table_robotocondensed_bold_90_4bpp.cpp table_robotocondensed_regular_110_4bpp.cpp table_robotocondensed_regular_22_4bpp.cpp table_robotocondensed_regular_38_4bpp.cpp table_robotocondensed_regular_54_4bpp.cpp unmappeddatafont.cpp vectorfontrendererbuffers.cpp
    ../cm7/touchgfx/generated/images/src/: bitmapdatabase.cpp svgdatabase.cpp
    ../cm7/touchgfx/generated/gui_generated/src/controls_screen/: controlsviewbase.cpp
    ../cm7/touchgfx/generated/gui_generated/src/common/: frontendapplicationbase.cpp
    ../cm7/touchgfx/generated/gui_generated/src/game2048_screen/: game2048viewbase.cpp
    ../cm7/touchgfx/generated/gui_generated/src/game2d_screen/: game2dviewbase.cpp
    ../cm7/touchgfx/generated/gui_generated/src/homeautomation_screen/: homeautomationviewbase.cpp
    ../cm7/touchgfx/generated/images/src/animatingbuttonsmenu/: image_animating_buttons_background.cpp image_animating_buttons_full_table_shadow_bottom.cpp image_animating_buttons_full_table_shadow_left.cpp image_animating_buttons_full_table_shadow_right.cpp image_animating_buttons_menu_icons_2048_tiny.cpp image_animating_buttons_menu_icons_controls_tiny.cpp image_animating_buttons_menu_icons_game_2d_tiny.cpp image_animating_buttons_menu_icons_home_automation_tiny.cpp image_animating_buttons_menu_icons_settings_tiny.cpp image_animating_buttons_table_element_shadow.cpp
    ../cm7/touchgfx/generated/images/src/game2048/: image_auto_play_button.cpp image_auto_play_button_pressed.cpp image_game_2048_background.cpp image_game_2048_dot_off.cpp image_game_2048_dot_on.cpp image_game_2048_game_over.cpp image_game_2048_menu_button.cpp image_game_2048_menu_button_pressed.cpp image_game_2048_you_win.cpp image_how_to_play_00.cpp image_how_to_play_01.cpp image_how_to_play_02.cpp image_how_to_play_background.cpp image_how_to_play_button.cpp image_how_to_play_button_pressed.cpp image_how_to_play_close_button.cpp image_new_game_button.cpp image_new_game_button_pressed.cpp image_tile_0002.cpp image_tile_0004.cpp image_tile_0008.cpp image_tile_0016.cpp image_tile_0032.cpp image_tile_0064.cpp image_tile_0128.cpp image_tile_0256.cpp image_tile_0512.cpp image_tile_1024.cpp image_tile_2048.cpp
    ../cm7/touchgfx/generated/images/src/homeautomation/: image_blinds_icon_32.cpp image_home_automation_background.cpp image_home_back_button.cpp image_home_back_button_pressed.cpp image_home_room_image_00.cpp image_home_room_image_01.cpp image_home_room_image_02.cpp image_home_room_image_03.cpp image_home_room_image_04.cpp image_home_room_image_05.cpp image_home_room_image_06.cpp image_home_room_image_07.cpp image_home_room_image_08.cpp image_home_room_image_09.cpp image_home_room_selected_light.cpp image_home_room_selected_lock.cpp image_lights_icon_32.cpp image_lock_icon_32.cpp image_main_button_blinds.cpp image_main_button_blinds_pressed.cpp image_main_button_light.cpp image_main_button_light_pressed.cpp image_main_button_security.cpp image_main_button_security_pressed.cpp image_main_button_statistics.cpp image_main_button_statistics_pressed.cpp image_statistics_gradient_blue.cpp image_statistics_gradient_blue_line.cpp image_statistics_gradient_green.cpp image_statistics_gradient_green_line.cpp image_statistics_gradient_red.cpp image_statistics_gradient_red_line.cpp image_statistics_lower.cpp image_statistics_upper.cpp
    ../cm7/touchgfx/generated/images/src/settings/: image_blue_glow.cpp image_clock_00_background.cpp image_clock_00_hour_hand.cpp image_clock_00_minute_hand.cpp image_clock_00_second_hand.cpp image_clock_01_background.cpp image_clock_01_hour_hand.cpp image_clock_01_minute_hand.cpp image_clock_01_second_hand.cpp image_clock_02_background.cpp image_clock_02_hour_hand.cpp image_clock_02_minute_hand.cpp image_clock_02_second_hand.cpp image_clock_settings_am.cpp image_clock_settings_circle.cpp image_clock_settings_circleselected.cpp image_clock_settings_colon.cpp image_clock_settings_pm.cpp image_date_picker_background.cpp image_date_picker_bar.cpp image_date_picker_shadow_bottom.cpp image_date_picker_shadow_top.cpp image_settings_button.cpp image_settings_button_pressed.cpp image_settings_calendar.cpp image_settings_done.cpp image_settings_done_pressed.cpp image_settings_next.cpp image_settings_next_pressed.cpp
    ../cm7/touchgfx/generated/images/src/controls/: image_board_image.cpp image_control_line_indicator.cpp image_controls_2dots.cpp image_controls_3dots.cpp image_controls_background.cpp image_dot_indicator_.cpp image_dot_indicator_highlighted.cpp image_icon_brightness_large.cpp image_icon_brightness_small.cpp image_menu_icon.cpp image_menu_icon_pressed.cpp image_slider.cpp image_slider_full.cpp image_slider_knop.cpp image_value_indicator_arrow.cpp image_value_indicator_circle.cpp image_value_indicator_glow.cpp image_value_indicator_wheel.cpp
    ../cm7/touchgfx/generated/images/src/carouselmenu/: image_carousel_background.cpp image_carousel_menu_icons_2048_large.cpp image_carousel_menu_icons_2048_medium.cpp image_carousel_menu_icons_2048_small.cpp image_carousel_menu_icons_controls_large.cpp image_carousel_menu_icons_controls_medium.cpp image_carousel_menu_icons_controls_small.cpp image_carousel_menu_icons_game_2d_large.cpp image_carousel_menu_icons_game_2d_medium.cpp image_carousel_menu_icons_game_2d_small.cpp image_carousel_menu_icons_home_automation_large.cpp image_carousel_menu_icons_home_automation_medium.cpp image_carousel_menu_icons_home_automation_small.cpp image_carousel_menu_icons_settings_large.cpp image_carousel_menu_icons_settings_medium.cpp image_carousel_menu_icons_settings_small.cpp
    ../cm7/touchgfx/generated/images/src/game2d/: image_collectible_item_00.cpp image_collectible_item_01.cpp image_collectible_item_02.cpp image_collectible_item_03.cpp image_collectible_item_04.cpp image_collectible_item_05.cpp image_collectible_item_06.cpp image_collectible_item_07.cpp image_collectible_item_08.cpp image_collectible_item_09.cpp image_game2d_background.cpp image_game2d_fly_button.cpp image_game2d_fly_button_pressed.cpp image_game2d_ground.cpp image_game2d_hw_button_off.cpp image_game2d_hw_button_off_pressed.cpp image_game2d_hw_button_on.cpp image_game2d_hw_button_on_pressed.cpp image_game2d_menu_button.cpp image_game2d_menu_button_pressed.cpp image_game2d_st_button_off.cpp image_game2d_st_button_off_pressed.cpp image_game2d_st_button_on.cpp image_game2d_st_button_pressed.cpp image_game2d_topleaves.cpp image_game2d_treetops.cpp image_game_2d_frame_background.cpp image_sphere1.cpp image_sprite_00.cpp image_sprite_01.cpp image_sprite_02.cpp image_sprite_03.cpp image_sprite_04.cpp image_sprite_05.cpp image_sprite_06.cpp image_sprite_07.cpp image_sprite_08.cpp image_sprite_09.cpp
    ../cm7/touchgfx/generated/images/src/homeautomation/login/: image_login_node_00.cpp image_login_node_01.cpp image_login_node_02.cpp image_login_node_03.cpp image_login_node_04.cpp image_login_node_05.cpp image_login_node_06.cpp image_login_node_07.cpp image_login_node_08.cpp image_login_node_09.cpp image_login_node_10.cpp image_login_node_11.cpp image_login_node_12.cpp image_login_node_13.cpp image_login_node_14.cpp image_login_node_15.cpp image_login_node_16.cpp image_login_node_17.cpp image_login_node_18.cpp image_login_node_19.cpp image_login_node_20.cpp image_login_node_21.cpp image_login_node_22.cpp image_login_node_23.cpp image_login_node_24.cpp image_login_node_25.cpp image_login_node_26.cpp image_login_node_27.cpp image_login_node_28.cpp
    ../cm7/touchgfx/generated/texts/src/: languagegbr.cpp texts.cpp typedtextdatabase.cpp
    ../cm7/touchgfx/generated/gui_generated/src/mainmenuanimatingbuttons_screen/: mainmenuanimatingbuttonsviewbase.cpp
    ../cm7/touchgfx/generated/gui_generated/src/mainmenucarousel_screen/: mainmenucarouselviewbase.cpp
    ../cm7/touchgfx/generated/gui_generated/src/containers/: mculoadwidgetbase.cpp
    ../cm7/touchgfx/generated/gui_generated/src/settings_screen/: settingsviewbase.cpp
target H757XI_SDRAM_Test_CM7 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H757XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.8.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x00000000-0xFFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: H757XI_SDRAM_Test_CM7 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: CORE_CM7,USE_HAL_DRIVER,STM32H757xx
  c include: ../CM7/Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../CM7/TouchGFX/App;../CM7/TouchGFX/target/generated;../CM7/TouchGFX/target;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../cm7/middlewares/st/touchgfx/framework/include;../cm7/touchgfx/generated/fonts/include;../cm7/touchgfx/generated/gui_generated/include;../cm7/touchgfx/generated/images/include;../cm7/touchgfx/generated/texts/include;../cm7/touchgfx/generated/videos/include;../cm7/touchgfx/gui/include
  asm include: ../CM7/Core/Inc
  memory RVCT1: ROM 0x90000000 size 0x3f80000
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x24000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x10000
software components: CMSIS:CORE 4.3.0
